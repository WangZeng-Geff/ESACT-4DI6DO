# Keil uVision project ESOS.uvproj, settings and files
target ESOS (ARM-ADS)
  device: ES8P508xFJXX ES
  cpu: IRAM(0x20000000-0x20003FFF)  IROM(0x00000000-0x00011FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: ESOS +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=3 oTime=1 OneElfS=1
  c misc: --gnu --bitband
  c include: Libraries\Library\Include;Libraries\CMSIS;.\;..\..\app;..\..\inc;..\..\os\inc;..\..\components\rtt
  library: MicroLIB
  memory RVCT4: ROM 0x1000 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../../app/: main.c dev.c plc_smart.c proto_smart.c update.c settings.c dev_show.c
    ../../app/report/: auto_report.c auto_report_app.c
  group src
    ../../src/: alloter.c bitmap.c bitops.c device.c kfifo.c object.c printk.c utils.c
    ../../src/drivers/: serial.c key.c
  group board
    ./: board.c encode.c irqhandler.c
    ./drivers/: es8p508_buz.c es8p508_flash.c es8p508_key.c es8p508_led.c es8p508_usart.c es8p508_adc.c es8p508_relay.c es8p508_zcp.c
  group components
    ../../components/shell/: cmds.c shell.c
    ../../components/rtt/: SEGGER_RTT.c
  group os
    ../../os/src/: croutine.c softtimer.c jiffies.c port.c
  group examples
    ../../examples/: test.c test_uart.c
  group Library
    ./Libraries/Library/Source/: lib_adc.c lib_flashiap.c lib_gpio.c lib_scs.c lib_scu.c lib_timer.c lib_uart.c lib_wdt.c lib_iap.c
  group StartUp
    ./startup/: startup_ES8P508x.s
  group CMSIS
    ./Libraries/CMSIS/: system_ES8P508x.c
