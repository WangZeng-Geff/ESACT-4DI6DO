# Keil uVision project es8p508_boot.uvproj, settings and files
target es8p508_boot (ARM-ADS)
  device: ES8P508xFJXX ES
  cpu: IRAM(0x20000000-0x20003FFF)  IROM(0x00000000-0x00011FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: hr8p508_boot +hex
  c flags: Optim=4 OneElfS=1
  c misc: --gnu --bitband
  c include: .\Libraries\CMSIS;.\;..\..\app;.\drivers;.\Libraries\Library\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group StartUp
    ./startup/: startup_ES8P508x.s
  group CMSIS
    ./Libraries/CMSIS/: system_ES8P508x.c
  group Library
    ./Libraries/Library/Source/: lib_flashiap.c lib_scs.c lib_scu.c lib_wdt.c lib_iap.c lib_uart.c lib_gpio.c
  group PlatForm
    ./: board.c
  group APP
    ../../app/: task.c update.c protocol.c fifo.c comfunc.c
