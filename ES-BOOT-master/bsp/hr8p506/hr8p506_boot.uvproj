# Keil uVision project hr8p506_boot.uvproj, settings and files
target hr8p506_boot (ARM-ADS)
  device: HR8P506FHLP HR
  cpu: IRAM(0x20000000-0x20001FFF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: hr8p506_boot +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1
  c misc: --gnu --bitband
  c include: .\Libraries\CMSIS;.\;..\..\app;.\drivers;.\Libraries\Library\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group StartUp
    ./startup/: startup_HR8P506.s
  group CMSIS
    ./Libraries/CMSIS/: system_HR8P506.c
  group Library
    ./Libraries/Library/Source/: lib_scs.c lib_scu.c lib_wdt.c lib_gpio.c lib_uart.c hr8p506_iap_table.c
  group PlatForm
    ./: board.c
  group APP
    ../../app/: fifo.c protocol.c task.c update.c comfunc.c
