# Keil uVision project hr8p296_boot.uvproj, settings and files
target hr8p296_boot (ARM-ADS)
  device: HR8P296 HR
  cpu: IRAM(0x20000000-0x20002FFF)  IROM(0x00000000-0x0001FFFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: hr8p296_boot +hex
  c flags: Optim=4 OneElfS=1
  c include: .\Libraries\CMSIS;.\;..\..\app;.\drivers;.\Libraries\Library\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\hr8p296_boot.sct
  group StartUp
    ./startup/: startup_HR8P296.s
  group CMSIS
    ./Libraries/CMSIS/: system_HR8P296.c
  group Library
    ./Libraries/Library/Source/: lib_flashiap.c lib_scs.c lib_scu.c lib_wdt.c
  group PlatForm
    ./: board.c
  group APP
    ../../app/: main.c
